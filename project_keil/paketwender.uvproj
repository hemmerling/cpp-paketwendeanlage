# Keil uVision project paketwender.uvproj, settings and files
target Target 1 (MCS-51)
  device: XC822MT-1F Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF1FF) IROM(0-0x0FFF) CLOCK(24000000) MODP2
  output: paketwender
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ../src/: getline.c sioirq.c siopoll.c rtos.h paketwender.c paketwender.h io.h
    ../asm/: START_XC82x.A51
